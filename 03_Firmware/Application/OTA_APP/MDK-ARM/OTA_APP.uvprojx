# Keil uVision project OTA_APP.uvprojx, settings and files
target OTA_APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: OTA_APP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,CMB_USER_CFG
  c include: ../00_Config;../01_APP;../02_Service/service_log;../02_Service/service_common;../02_Service/service_common/crc;../02_Service/service_firmware;../02_Service/service_ota;../02_Service/service_uart;../02_Service/service_ymodem;../03_Platform/platform_common;../03_Platform/platform_bsp;../03_Platform/platform_bsp/led;../03_Platform/platform_bsp/w25q64;../03_Platform/platform_bsp/at24c02;../03_Platform/platform_bsp/st7789;../03_Platform/platform_bsp/key;../03_Platform/platform_graphics;../03_Platform/platform_graphics/font;../03_Platform/platform_mcu/gpio;../03_Platform/platform_mcu/irq;../03_Platform/platform_mcu/reset;../03_Platform/platform_mcu/i2c;../03_Platform/platform_mcu/spi;../03_Platform/platform_mcu/uart;../03_Platform/platform_middleware;../03_Platform/platform_os;../04_Impl/impl_board;../04_Impl/impl_bsp;../04_Impl/impl_mcu;../04_Impl/impl_os;../04_Impl/impl_os/freertos;../04_Impl/impl_middleware/impl_log;../04_Impl/impl_diagnostics;../05_Vendors/easylogger/inc;../05_Vendors/RTT;../05_Vendors/CmBacktrace;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/04_Impl/Diagnostics
    ../04_Impl/impl_diagnostics/: cmbacktrace_port.c cmbacktrace_fault_handlers.S diagnostics_fault_trigger.S diagnostics_fault.c
  group Application/05_Vendors/CmBacktrace
    ../05_Vendors/CmBacktrace/: cm_backtrace.c
  group Application/01_APP
    ../01_APP/: app_main.c app_display_task.c app_ota_worker.c app_ota_runtime.c app_system.c
  group Application/02_Service/Service Log
    ../02_Service/service_log/: service_log.c
  group Application/02_Service/Firmware
    ../02_Service/service_common/crc/: crc.c
    ../02_Service/service_firmware/: firmware_version.c firmware_image.c firmware_metadata.c firmware_storage.c ota_firmware_sink.c
  group Application/02_Service/OTA
    ../02_Service/service_ota/: service_ota.c
  group Application/02_Service/UART
    ../02_Service/service_common/: ring_buffer.c
    ../02_Service/service_uart/: service_uart.c
  group Application/02_Service/YMODEM
    ../02_Service/service_ymodem/: ymodem_parser.c ymodem_receiver.c
  group Application/03_Platform
    ../03_Platform/platform_common/: platform_device.c platform_object.c
    ../03_Platform/platform_bsp/led/: platform_bsp_led.c platform_led.c
    ../03_Platform/platform_mcu/gpio/: platform_gpio.c
    ../03_Platform/platform_mcu/irq/: platform_mcu_irq.h
    ../03_Platform/platform_mcu/reset/: platform_mcu_reset.h
    ../03_Platform/platform_bsp/key/: platform_key.c
    ../03_Platform/platform_mcu/i2c/: platform_i2c.c
    ../03_Platform/platform_mcu/spi/: platform_spi.c
    ../03_Platform/platform_bsp/w25q64/: platform_w25q64.c platform_bsp_w25q64.c
    ../03_Platform/platform_bsp/at24c02/: platform_at24c02.c
    ../03_Platform/platform_mcu/uart/: platform_uart.c
    ../03_Platform/platform_bsp/st7789/: platform_bsp_st7789.c platform_st7789.c
    ../03_Platform/platform_graphics/: platform_graphics.c
    ../03_Platform/platform_graphics/font/: platform_font_ascii_8x16.c
  group Application/04_Impl
    ../04_Impl/impl_bsp/: impl_platform_bsp_gpio.c impl_platform_bsp_spi.c impl_platform_bsp_uart.c impl_platform_bsp_key.c
    ../04_Impl/impl_mcu/: impl_platform_gpio.c impl_platform_spi.c impl_platform_delay.c impl_platform_uart.c impl_dma.c impl_platform_mcu_irq.c impl_platform_mcu_reset.c
    ../04_Impl/impl_os/freertos/: impl_freertos_time.c impl_freertos_thread.c impl_freertos_queue.c impl_freertos_notify.c
    ../04_Impl/impl_middleware/impl_log/: easylogger_port.c
  group Application/05_Vendors/EasyLogger
    ../05_Vendors/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../05_Vendors/easylogger/port/: elog_port.c
  group Application/05_Vendors/RTT
    ../05_Vendors/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0
