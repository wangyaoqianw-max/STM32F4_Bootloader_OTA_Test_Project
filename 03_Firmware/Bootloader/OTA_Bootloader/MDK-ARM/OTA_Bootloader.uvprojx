# Keil uVision project OTA_Bootloader.uvprojx, settings and files
target OTA_Bootloader (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: OTA_Bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,CMB_USER_CFG
  c include: ../Core/Inc;../Boot;../Config;../Diagnostics;../Firmware;../Vendor;../Vendor/RTT;../Vendor/CmBacktrace;../../../Shared;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Boot
    ../Boot/: boot_main.c boot_validate.c boot_jump.c boot_jump_asm.S
  group Firmware
    ../Firmware/: boot_crc32.c boot_image.c boot_metadata.c
  group Diagnostics
    ../Diagnostics/: boot_log.c cmbacktrace_port.c diagnostics_fault.c diagnostics_fault_trigger.S cmbacktrace_fault_handlers.S
  group Vendor/RTT
    ../Vendor/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Vendor/CmBacktrace
    ../Vendor/CmBacktrace/: cm_backtrace.c
