# Keil uVision project W25Q64_STM32F411.uvprojx, settings and files
target W25Q64_STM32F411 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x0-0x100) CLOCK(16000000) FPU2 CPUTYPE("Cortex-M4")
  output: W25Q64_STM32F411
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32F411xE
  c include: ../Includes;../Includes/CMSIS;../Includes/Loader;../Sources/Loader;../../../../03_Firmware/Application/OTA_APP/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../03_Firmware/Application/OTA_APP/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x101
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ExternalLoader.sct
  link misc: --entry=Init --no_remove
  group Loader/Source
    ../Sources/Loader/: Dev_Inf.c Loader_Src.c
  group Loader/Headers
    ../Includes/Loader/: Dev_Inf.h Loader_Src.h
